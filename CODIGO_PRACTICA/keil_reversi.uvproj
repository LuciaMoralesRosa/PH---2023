# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c SWI.s conecta_k_hay_linea_arm_arm.s
  group Source Code
    ./: main.c temporizador_hal.c temporizador_hal.h temporizador_drv.c temporizador_drv.h eventos.h gpio_hal.c gpio_hal.h FIFO.c FIFO.h io_reserva.h definiciones.h planificador.c power.c power.h alarma.c alarma.h swi.h WD.c WD.h linea_serie_hal.c linea_serie_hal.h linea_serie_drv.c linea_serie_drv.h planificador.h juego.c juego.h botones.c botones.h int_externas_hal.c int_externas_hal.h hello_world.c hello_world.h visualizar.c visualizar.h
  group conectaK
    ./: conecta_K_2023.c entrada.c tablero.c celda.h conecta_K_2023.h config_conecta_K.h entrada.h tablero.h tablero_test.h
